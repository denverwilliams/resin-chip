SUPERVISOR_REPOSITORY_chip = "resin/armv7hf-supervisor"
LED_FILE_chip = "/dev/null"
