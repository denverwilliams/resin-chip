# IMAGE_FSTYPES_meta-chip defined in meta-chip